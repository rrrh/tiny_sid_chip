** sch_path: verification/pwm_comp/cace/templates/dc_transfer.sch
**.subckt dc_transfer
**** begin user architecture code

.lib cornerMOSlv.lib CACE{corner}




* DUT netlist
.include CACE{DUT_path}

* Parameters
.param vdd_val = CACE{vdd}

* Temperature
.temp CACE{temperature}

* Power supplies
Vdd  vdd 0 {vdd_val}
Vss  vss 0 0

* Input: sweep Vinp, hold Vinn at mid-rail
Vvinp vinp 0 0
Vvinn vinn 0 {vdd_val/2}

* Output load
Rload out 0 1meg

* DUT instantiation
Xcomp vinp vinn out vdd vss pwm_comp

* DC sweep: Vinp from 0 to VDD, 5mV steps
.control
  dc Vvinp 0 CACE{vdd} 0.005
  wrdata CACE{simpath}/CACE{filename}_CACE{N}.data v(out)
  quit
.endc

.end


**** end user architecture code
**.ends
.end
